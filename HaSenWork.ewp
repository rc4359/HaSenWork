# IAR project HaSenWork.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 256
  General.GHeapSize2: 256
  General.RadioHeapSizeType: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group ADXL345
    ADXL345/: ADXL345.c ADXL345.h
  group Header
    Header/: data.h IO.h RFID.h type.h Uer.h
  group HMC5883L
    HMC5883L/: HMC5883L.c HMC5883L.h
  group i2c
    i2c/: i2c.c i2c.h
  group L3G4200D
    L3G4200D/: L3G4200D.c L3G4200D.h
  group main
    scr/: main.c
  group spi
    SPI/: SPI.c SPI.h
  group uz2400
    Uz2400/: uz2400.c uz2400.h uz2400Header.h
